#include "define.zhh"
//-------------------------------------------------------------------------------------------------------------------
//  @brief      软件延时函数//内部时钟频率33.1776Mhz
//  @param      x            	需要延时的时间（ms）
//  @return     void
//  Sample usage:               无需用户调用，用户请使用h文件中的宏定义
//------------------------------------------------------------------------------------------------------------------
void delay_ms(uint16 x)
{
    uint8 i,j;
    while(x--)
    {
		_nop_();
		_nop_();
		i = 44;
		j = 19;
		do
		{
			while (--j);
		} while (--i);
    }
}


//-------------------------------------------------------------------------------------------------------------------
//  @brief      软件延时函数//内部时钟频率33.1776Mhz
//  @param      x            	需要延时的时间（us）
//  @return     void
//  Sample usage:               无需用户调用，用户请使用h文件中的宏定义
//-------------------------------------------------------------------------------------------------------------------
void delay_us(uint16 x)
{
    uint8 i;
    while(x--)
    {
		i = 9;
		while (--i);
    }
}
