# Keil uVision project 111.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 111 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\STD_LIB
  group Source Group 1
    ./user/: delay.c main.c uart.c
  group New Group
    ./STD_LIB/: STC8G_H_ADC.c STC8G_H_ADC_Isr.c STC8G_H_Compare.c STC8G_H_Compare_Isr.c STC8G_H_Delay.c STC8G_H_EEPROM.c STC8G_H_Exti.c STC8G_H_Exti_Isr.c STC8G_H_GPIO.c STC8G_H_GPIO_Isr.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_Soft_I2C.c STC8G_H_Soft_UART.c STC8G_H_SPI.c STC8G_H_SPI_Isr.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_WDT.c STC8G_PCA.c STC8G_PCA_Isr.c STC8G_PWM15bit.c STC8G_PWM15bit_Isr.c
